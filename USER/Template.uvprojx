# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\FWlib\inc;..\startup;..\Motor;..\CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c led.c mpu6050.c indkey.c delay.c misc.c stm32f10x_it.c lcd12864.c
  group Motor
    ../Motor/: Motor_Control.c Motor_PID.c Motor_PWM.c chuanjiPID.c
  group CMSYS
    ../CM3/: core_cm3.c system_stm32f10x.c
    ./: sys.c
  group FWLIb
    ../FWlib/SRC/: stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dbgmcu.c
  group ASM
    ../startup/: startup_stm32f10x_hd.s
